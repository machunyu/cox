# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: xDEBUG; EWARM
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\libcox; ..\..\..\..\startup; ..\..\..\..\testframe; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xspi.h xsysctl.h
  group libcox_src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xspi.c xsysctl.c
  group Source
    ../../../../testframe/: main.c test.c testport.c
  group test
    ../src/: spitest00.c spitest01.c spitest02.c spitest03.c spitest04.c testcase.c
