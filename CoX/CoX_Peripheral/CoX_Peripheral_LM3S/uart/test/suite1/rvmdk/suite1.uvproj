# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: suite1
  c flags: Optim=1
  c define: rvmdk xDEBUG
  c include: ..\..\..\..\startup\src;..\..\..\..\libcox;..\..\..\..\startup\src;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.h xuart.h xcore.h xdebug.h xgpio.h xdma.h xhw_dma.h xhw_timer.h
  group libcox_src
    ../../../../libcox/: xuart.c xcore.c xdebug.c xgpio.c xsysctl.c xdma.c xtimer.c
  group Source
    ../../../../testframe/: main.c test.c testport.c
  group test
    ../src/: testcase.c xuarttest.c
