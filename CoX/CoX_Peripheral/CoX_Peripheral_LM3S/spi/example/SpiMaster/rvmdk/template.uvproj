# Keil uVision project template.uvproj, settings and files
target example (ARM-ADS)
  device: LM3S9B96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\src;..\..\SpiMaster;..\..\..\..\libcox;..\..\..\..\startup\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xuart.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h
  group libcox_src
    ../../../../libcox/: xuart.c xcore.c xdebug.c xgpio.c xspi.c xsysctl.c
  group app
    ../src/: SpiMaster.c
  group user
    ../: main.c
