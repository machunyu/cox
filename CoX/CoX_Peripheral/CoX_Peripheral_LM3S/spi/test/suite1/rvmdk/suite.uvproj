# Keil uVision project suite.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: suite
  c flags: Optim=1
  c define: xDEBUG
  c include: ..\src;..\..\..\..\startup\src;..\..\..\..\libcox;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../libcox/: xspi.h xsysctl.h xcore.h xdebug.h xgpio.h xhw_ints.h xhw_spi.h xhw_sysctl.h xhw_types.h
  group libcox_src
    ../../../../libcox/: xuart.c xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xdma.c
  group Source
    ../../../../testframe/: main.c test.c testport.c
  group test
    ../src/: spitest00.c spitest01.c spitest02.c spitest03.c testcase.c
