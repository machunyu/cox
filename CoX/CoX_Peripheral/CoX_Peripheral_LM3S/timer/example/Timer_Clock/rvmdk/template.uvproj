# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c include: ..\rvmdk;..\..\..\..\startup\src;..\..\..\..\libcox
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry ResetHandler
  group rvmdk
    ./: startup_rvmdk.s
  group Cox_Peripheral
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xsysctl.c xtimer.c xuart.c
  group example
    ../src/: one_second_clock.c
  group Source
    ../: main.c
